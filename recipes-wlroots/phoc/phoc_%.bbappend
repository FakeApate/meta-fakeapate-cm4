FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-wlroots-fix-Xwayland-header-include-path-and-guard-w.patch"


DEPENDS:append = " gcr3"
DEPENDS:remove = " gcr"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://phosh.pam"
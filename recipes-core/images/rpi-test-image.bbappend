

IMAGE_INSTALL += "\
  packagegroup-fcm4-base \
  packagegroup-fcm4-network \
  packagegroup-fcm4-power \
  packagegroup-fcm4-ota \
  packagegroup-fcm4-ui \
  packagegroup-fcm4-firmware \
"
